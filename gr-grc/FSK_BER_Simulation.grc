options:
  parameters:
    author: surligas
    generate_options: no_gui
    id: FSK_BER_Simulation
    output_language: python
    run_options: run
    title: FSK BER Simulation
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    value: '1'
  states: {}
- name: gaussian_taps
  id: variable
  parameters:
    value: filter.firdes.gaussian(1.0, sps, 1.0, 4*sps)
  states: {}
- name: interp_taps
  id: variable
  parameters:
    value: numpy.convolve(numpy.array(gaussian_taps), numpy.array(sq_wave))
  states: {}
- name: modulation_index
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: sq_wave
  id: variable
  parameters:
    value: (1.0, ) * sps
  states: {}
- name: variable_ieee802_15_4_encoder_0
  id: variable_ieee802_15_4_encoder
  parameters:
    crc: satnogs.crc.CRC32_C
    preamble: '0x55'
    preamble_len: '12'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc: satnogs.crc.CRC32_C
    drop_invalid: 'True'
    frame_len: '255'
    preamble: '[0x55]*12'
    preamble_thrsh: '14'
    rs: 'False'
    sync_thrsh: '5'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_2
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc: satnogs.crc.CRC32_C
    drop_invalid: 'False'
    frame_len: '255'
    preamble: '[0x55]*8'
    preamble_thrsh: '12'
    rs: 'False'
    sync_thrsh: '3'
    sync_word: '[49, 229]'
    var_len: 'True'
    whitening: satnogs.whitening_sptr(None)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (math.pi*modulation_index) / sps
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_GAUSSIAN
    mean: '1'
    msg: pmt.intern("TEST")
    std: '4'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps * 8
    lengthtagname: packet_len
    type: complex
  states: {}
- name: cfo
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: cfo/(samp_rate*sps)
    noise_voltage: math.sqrt(  (sps*(2*bits_per_symbol)) * math.pow(10, -snr/10))
    seed: int(random.random() * 100)
    taps: 1 + 1j
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_burst_shaper_xx_0_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '1500'
    pre_padding: '0'
    type: complex
    window: ([])
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi/200
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '8'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: |-
      Do not forget to set the 
      filter delay! Otherwise the
      burst shaper wll split the
      frame in an appropriate place!
    interp: sps
    samp_delay: len(interp_taps)//sps
    taps: interp_taps
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate * (sps //8)
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate / 2
    decim: '1'
    gain: '1'
    interp: '4'
    samp_rate: samp_rate * (sps //8)
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*sps
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: sps//8
    fbw: ''
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: satnogs_ber_calculator_0
  id: satnogs_ber_calculator
  parameters:
    frame_size: '64'
    nframes: '10000'
    skip: '0'
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    encoder_object: variable_ieee802_15_4_encoder_0
  states: {}
- name: snr
  id: parameter
  parameters:
    type: eng_float
    value: '13'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: samples per symbol
    type: intx
    value: '32'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', dc_blocker_xx_0, '0']
- [blocks_message_strobe_random_0, strobe, satnogs_ber_calculator_0, trigger]
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_tagged_stream_align_0, '0', digital_burst_shaper_xx_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_align_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', low_pass_filter_1, '0']
- [digital_binary_slicer_fb_0, '0', satnogs_frame_decoder_0, '0']
- [digital_burst_shaper_xx_0_0, '0', channels_channel_model_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_1, '0', digital_symbol_sync_xx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [satnogs_ber_calculator_0, pdu, satnogs_frame_encoder_0, pdu]
- [satnogs_frame_decoder_0, out, satnogs_ber_calculator_0, received]
- [satnogs_frame_encoder_0, pdu, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
