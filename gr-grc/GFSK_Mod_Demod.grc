options:
  parameters:
    author: EnduroSat
    generate_options: qt_gui
    id: GFSK_Mod_Demod
    output_language: python
    title: GFSK_Mod_Demod
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: int(430e6)
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 960e3
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: 96e3
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 1024//2
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4096'
    scale: 1.0/1024.0
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: '"preamble_start_tx"'
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '100'
    minsize: '80'
  states: {}
- name: blocks_random_pdu_0_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '40'
    minsize: '20'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: Generate Binary Stream
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: baudrate*decimation
    sensitivity: '-baudrate*decimation'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '01111110'
    comment: Max 64 bits allowed.
    tagname: '"DF1_start"'
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_gfsk_mod_0_0
  id: digital_gfsk_mod
  parameters:
    bt: '1.0'
    samples_per_symbol: '10'
    sensitivity: 2*np.pi*deviation/samp_rate_2
  states: {}
- name: digital_gmsk_mod_1
  id: digital_gmsk_mod
  parameters:
    bt: '1'
    samples_per_symbol: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * baudrate
    decim: decimation // 2
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 8.0
    win: firdes.WIN_BLACKMAN
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Perform a relaxed filter to increase 
      the performance of the auto frequency
      correction
    cutoff_freq: baudrate*1.25
    decim: '1'
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 2.0
    win: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_2
    fc: '0'
    fftsize: '512'
    label1: '"GFSK"'
    label2: '"GMSK"'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Delay 1ms Added
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    name: '"Transmitter - Modulated Data"'
    size: '450'
    srate: '9600'
    tr_delay: '0.001'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_slope: qtgui.TRIG_SLOPE_NEG
    tr_tag: '"preamble_start_tx"'
    type: float
    ymax: '1.2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Delay 1ms Added
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"Transmitter - Modulated Data"'
    size: '4200'
    srate: '9600'
    tr_delay: '0.001'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_slope: qtgui.TRIG_SLOPE_NEG
    tr_tag: '"preamble_start_tx"'
    type: complex
    ymax: '1.2'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Delay 1ms Added
    ctrlpanel: 'True'
    grid: 'True'
    label1: ''
    name: '"Transmitter - Modulated Data"'
    size: '700'
    srate: '9600'
    tr_delay: '0.001'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_slope: qtgui.TRIG_SLOPE_NEG
    tr_tag: '"preamble_start_tx"'
    type: float
    ymax: '1.2'
    ymin: '0'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: baudrate
    iq: 'True'
    options: '"--use_agc"'
    samp_rate: baudrate*decimation / (decimation // 2)
    subaudio: 'False'
  states: {}
- name: si446x_var_len_packet_handler_1_0
  id: si446x_var_len_packet_handler
  parameters:
    check_crc: 'False'
    crc_poly: '4129'
    has_crc: 'True'
    sync: '0xAA7E'
  states: {}
- name: var_len_packet_creator_0
  id: var_len_packet_creator
  parameters:
    crc_poly: '4129'
    has_crc: 'True'
    preamble_bytes: '16'
    sync: '0xAA7E'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: byte_stream
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: |-
      Samples per Symbol = 10
      -> Baudrate * 10
      e.g 9600 => 96000
    stream_id: quadrature_modulated_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: byte_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: quadrature_modulated_signal
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: filtered
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', virtual_sink_0, '0']
- [blocks_random_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_random_pdu_0, pdus, var_len_packet_creator_0, in]
- [blocks_random_pdu_0_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_random_pdu_0_0, pdus, var_len_packet_creator_0, in]
- [blocks_repack_bits_bb_1, '0', digital_gfsk_mod_0_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_gmsk_mod_1, '0']
- [blocks_uchar_to_float_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [digital_binary_slicer_fb_0, '0', si446x_var_len_packet_handler_1_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_uchar_to_float_1_0, '0']
- [digital_gfsk_mod_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gmsk_mod_1, '0', qtgui_freq_sink_x_0, '1']
- [digital_gmsk_mod_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_gmsk_mod_1, '0', virtual_sink_1, '0']
- [low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [satellites_fsk_demodulator_0, '0', digital_binary_slicer_fb_0, '0']
- [satellites_fsk_demodulator_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [si446x_var_len_packet_handler_1_0, out, blocks_message_debug_0_0, print_pdu]
- [var_len_packet_creator_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', blocks_repack_bits_bb_1, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']
- [virtual_source_1, '0', low_pass_filter_0_0, '0']
- [virtual_source_1_0, '0', satellites_fsk_demodulator_0, '0']

metadata:
  file_format: 1
