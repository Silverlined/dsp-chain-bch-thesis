options:
  parameters:
    author: EnduroSat
    copyright: EnduroSat
    generate_options: hb
    id: UHF_GMSK_Demod_Hier
    output_language: python
    title: UHF_GMSK_Demod_Hier
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: baudrate+2*deviation
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: pulse_shaping_filter_taps
  id: variable
  parameters:
    value: np.ones( sqfilter_len ) / sqfilter_len
  states: {}
- name: sps
  id: variable
  parameters:
    value: int( baudrate * decimation / (lp_decimation) / baudrate )
  states: {}
- name: sqfilter_len
  id: variable
  parameters:
    value: int( baudrate * decimation / (decimation // 2) / baudrate )
  states: {}
- name: agc_reference
  id: parameter
  parameters:
    label: AGC Reference
    type: eng_float
    value: '1.0'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Gain = sample rate / 2 * pi * frequency deviation
    gain: ( baudrate * decimation / lp_decimation ) / ( 2 * np.pi * deviation )
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Get frequency offset
    gain: '1.0'
  states: {}
- name: baudrate
  id: parameter
  parameters:
    label: Data rate
    type: intx
    value: int(9.6e3)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Avoid division by zero
    const: '1e-20'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 1024//2
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4096'
    scale: 1.0/1024.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: agc_reference
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Shift to remove frequency offset
    type: complex
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: rms_alpha
    comment: |-
      τ=−1/log(1−α)
      α=0.01 -> ≈99.5 samples
      for sps=2 -> ≈50 symbols ≈6 bytes
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    comment: Generate signal impulse at the offset frequency
    samp_rate: baudrate*decimation
    sensitivity: '-baudrate*decimation'
  states: {}
- name: clk_bw
  id: parameter
  parameters:
    label: Clock Recovery BW (relative to baudrate)
    type: eng_float
    value: '0.06'
  states: {}
- name: clk_limit
  id: parameter
  parameters:
    label: Clock Recovery Limit (relative to baudrate)
    type: eng_float
    value: '0.004'
  states: {}
- name: cutoff_freq
  id: parameter
  parameters:
    label: LP Filter Cutoff [Hz]
    type: intx
    value: '9600'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: Frequency Deviation
    type: intx
    value: '2400'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 'clk_bw '
    max_dev: clk_limit * sps
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: ted_gain
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      The input pulses must have peaks (not flat),
      which usually can be implemented by using a matched filter
      before clock recovery.
    decim: '1'
    taps: pulse_shaping_filter_taps
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Every halving of Rx filter bandwidth increases sensitivity with 3 dB
      On the other hand, sensitivity decreases with about 1.5-2.5 dB per halving of the modulation index
      to a certain limit where the loss increases very fast
      (Wouldn't go below a modulation index less than 0.5).
    cutoff_freq: cutoff_freq
    decim: lp_decimation
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 8.0
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Perform a relaxed filter to increase 
      the performance of the auto frequency
      correction
    cutoff_freq: bandwidth
    decim: '1'
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 4.0
    win: firdes.WIN_HAMMING
  states: {}
- name: lp_decimation
  id: parameter
  parameters:
    label: LP Decimation [2-48, 5-19.2]
    type: intx
    value: '5'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rms_alpha
  id: parameter
  parameters:
    comment: |-
      τ=−1/log(1−α)
      α=0.01 -> ≈99.5 samples
      for sps=2 -> ≈50 symbols ≈6 bytes
    label: RMS Gain
    type: eng_float
    value: '0.02'
  states: {}
- name: ted_gain
  id: parameter
  parameters:
    label: TED Gain
    type: eng_float
    value: '1.47'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_sink_0_0_2
  id: virtual_sink
  parameters:
    stream_id: equalized
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: equalized
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: |-
      Rx receiver's filter BW = Signal BW + 2 * ppm * Carrier Frequency

      The occupied bandwidth for 98% of the transmitted power
      is determined from Carson’s Rule:

      Signal BW = 2*f_deviation + data_rate

      Due to Gaussian pulse shaping,higher frequency components are supressed,
      i.e. the actual occupied bandwidth is slightly smaller.
    stream_id: filtered
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_divide_xx_0, '0', virtual_sink_0_0_2, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [digital_symbol_sync_xx_0, '0', pad_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_divide_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_rms_xx_0, '0']
- [low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_1, '0', analog_quadrature_demod_cf_0, '0']

metadata:
  file_format: 1
