options:
  parameters:
    author: EnduroSat
    copyright: EnduroSat
    generate_options: qt_gui
    id: UHF_RX_TX_TEST
    output_language: python
    title: UHF_RX_TX_TEST
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: baudrate+2*deviation
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: lo_offset
  id: variable
  parameters:
    value: int(100e3)
  states: {}
- name: max_freq_offset
  id: variable
  parameters:
    value: ppm * rx_freq / 1e6
  states: {}
- name: ppm
  id: variable
  parameters:
    value: 2.5+4
  states: {}
- name: pulse_shaping_filter_taps
  id: variable
  parameters:
    value: np.ones( sqfilter_len ) / sqfilter_len
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1.92e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: int( baudrate * decimation / (decimation // 2) / baudrate )
  states: {}
- name: sqfilter_len
  id: variable
  parameters:
    value: int( baudrate * decimation / (decimation // 2) / baudrate )
  states: {}
- name: agc_reference
  id: parameter
  parameters:
    label: AGC Reference
    type: eng_float
    value: '1.0'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Gain = sample rate / 2 * pi * frequency deviation
    gain: ( baudrate * decimation / (decimation // 2) ) / ( 2 * np.pi * deviation )
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Get frequency offset
    gain: '1.0'
  states: {}
- name: baudrate
  id: parameter
  parameters:
    label: Data rate
    type: intx
    value: int(9.6e3)
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: Avoid division by zero
    const: '1e-20'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 1024//2
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/silverlined/Documents/vm-shared/iq_esps_1M92.dat
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4096'
    scale: 1.0/1024.0
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: agc_reference
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Shift to remove frequency offset
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    comment: |-
      Generate Byte Stream
      Pack bits into stream of bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: rms_alpha
    comment: |-
      τ=−1/log(1−α)
      α=0.01 -> ≈99.5 samples
      for sps=2 -> ≈50 symbols ≈6 bytes
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    comment: Generate signal impulse at the offset frequency
    samp_rate: baudrate*decimation
    sensitivity: '-baudrate*decimation'
  states: {}
- name: clk_bw
  id: parameter
  parameters:
    label: Clock Recovery BW (relative to baudrate)
    type: eng_float
    value: '0.06'
  states: {}
- name: clk_limit
  id: parameter
  parameters:
    label: Clock Recovery Limit (relative to baudrate)
    type: eng_float
    value: '0.004'
  states: {}
- name: deviation
  id: parameter
  parameters:
    label: Frequency Deviation
    type: intx
    value: '2400'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '1.0'
    samples_per_symbol: '10'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 'clk_bw '
    max_dev: clk_limit * sps
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: sps
    ted_gain: '1.47'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: |-
      The input pulses must have peaks (not flat),
      which usually can be implemented by using a matched filter
      before clock recovery.
    decim: '1'
    taps: pulse_shaping_filter_taps
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iocp_endurosat_IOCP_CLIENT_PDU_0
  id: iocp_endurosat_IOCP_CLIENT_PDU
  parameters:
    address: 127.0.0.1
    port: '6666'
    type: '100'
  states: {}
- name: iocp_endurosat_TAG_TRIGGER_0
  id: iocp_endurosat_TAG_TRIGGER
  parameters:
    filter: nPktSeqNum
    type: complex
    vlen: '1'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    channel_mode: '0'
    gain_dB_ch0: '60'
    length_tag_name: '"preamble_start_tx"'
    oversample: '0'
    pa_path_ch0: '2'
    rf_freq: tx_freq
    samp_rate: samp_rate
    serial: 0009070602460F25
  states: {state: disabled}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: rx_freq-lo_offset
    samp_rate: samp_rate
    serial: 0009070602460F25
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Every halving of Rx filter bandwidth increases sensitivity with 3 dB
      On the other hand, sensitivity decreases with about 1.5-2.5 dB per halving of the modulation index
      to a certain limit where the loss increases very fast
      (Wouldn't go below a modulation index less than 0.5).
    cutoff_freq: baudrate
    decim: decimation // 2
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 8.0
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Perform a relaxed filter to increase 
      the performance of the auto frequency
      correction
    cutoff_freq: bandwidth
    decim: '1'
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 4.0
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: baudrate*decimation/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: baudrate*decimation/4
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: baudrate+2*deviation
    decim: '1'
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate*decimation/64
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  GMSK Modulation, Interpolation with Reconstruction Filter
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  One-bit Differential Detection & Automatic Gain Control
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Doppler compensation with Digital Down Conversion
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Auto Frequency Correction, Decimation with Anti-Aliasing Filter
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0_2
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Radio Packet Parsing
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0_2_0
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Clock Recovery & Hard Decision Decoding
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_0_2_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  AX.25 Parsing
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_1
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Parameters & Variables
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: note_0_1_2
  id: note
  parameters:
    comment: |-
      .                                                                                                                                                                                                                                  Radio Packet Encapsulation
      ------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
    note: SECTION
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: ( baudrate * decimation / (decimation // 2) )
    ctrlpanel: 'True'
    fc: rx_freq
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baudrate * decimation
    ctrlpanel: 'True'
    fc: rx_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
    ymax: '0'
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baudrate * decimation
    ctrlpanel: 'True'
    fc: rx_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN
    ymax: '0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baudrate * decimation
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: baudrate*decimation
    fbw: ''
    interp: samp_rate
    taps: ''
    type: ccc
  states: {}
- name: rms_alpha
  id: parameter
  parameters:
    comment: |-
      τ=−1/log(1−α)
      α=0.01 -> ≈99.5 samples
      for sps=2 -> ≈50 symbols ≈6 bytes
    label: RMS Gain
    type: eng_float
    value: '0.02'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 4176620F
    label: RX Frequency
    type: intx
    value: int(435e6)
  states: {}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    fine_correction: '0'
    lo_offset: lo_offset
    out_samp_rate: baudrate * decimation
    samp_rate: samp_rate
    sat_freq: rx_freq
  states: {}
- name: satnogs_doppler_compensation_0_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    fine_correction: '0'
    lo_offset: '0'
    out_samp_rate: samp_rate
    samp_rate: samp_rate
    sat_freq: tx_freq
  states: {}
- name: si446x_var_len_packet_handler_1_0
  id: si446x_var_len_packet_handler
  parameters:
    check_crc: 'True'
    crc_poly: '4129'
    has_crc: 'True'
    sync: '0xAA7E'
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    comment: 4162270E
    label: TX Frequency
    type: intx
    value: int(434e6)
  states: {}
- name: var_len_packet_creator_0
  id: var_len_packet_creator
  parameters:
    comment: |-
      The modulator needs some time to stabilize as the 
      modulated carrier wave goes from zero up to full power.
      Therefore, extra preamble and postamble bytes were added to each transmitted packet.

      The output is an unpacked binary stream.
    crc_poly: '4129'
    has_crc: 'True'
    preamble_bytes: '20'
    sync: '0xAA7E'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tagged_stream
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: doppler
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: binary_stream
  states: {}
- name: virtual_sink_0_0_2
  id: virtual_sink
  parameters:
    stream_id: equalized
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: tunnel_out
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: confirm_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: rx_freq
  states: {state: disabled}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: tx_freq
  states: {state: disabled}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: tunnel_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tagged_stream
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: doppler
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: equalized
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: binary_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: |-
      Rx receiver's filter BW = Signal BW + 2 * ppm * Carrier Frequency

      The occupied bandwidth for 98% of the transmitted power
      is determined from Carson’s Rule:

      Signal BW = 2*f_deviation + data_rate

      Due to Gaussian pulse shaping,higher frequency components are supressed,
      i.e. the actual occupied bandwidth is slightly smaller.
    stream_id: filtered
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: tunnel_in
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: confirm_tx
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: tunnel_out
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '0']
- [blocks_divide_xx_0, '0', virtual_sink_0_0_2, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_null_source_0, '0', blocks_throttle_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', virtual_sink_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_gmsk_mod_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', satnogs_doppler_compensation_0, '0']
- [blocks_throttle_0_0, '0', blocks_null_sink_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [digital_binary_slicer_fb_0, '0', virtual_sink_0_0_1, '0']
- [digital_gmsk_mod_0, '0', low_pass_filter_2, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [fir_filter_xxx_0, '0', blocks_divide_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_rms_xx_0, '0']
- [iocp_endurosat_IOCP_CLIENT_PDU_0, out, virtual_sink_1, '0']
- [iocp_endurosat_TAG_TRIGGER_0, event, virtual_sink_1_0, '0']
- [limesdr_source_0, '0', satnogs_doppler_compensation_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [low_pass_filter_1, '0', satnogs_doppler_compensation_0_0, '0']
- [low_pass_filter_2, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [satnogs_doppler_compensation_0, '0', qtgui_freq_sink_x_1_0, '0']
- [satnogs_doppler_compensation_0, '0', virtual_sink_0_0_0, '0']
- [satnogs_doppler_compensation_0_0, '0', blocks_throttle_0_0, '0']
- [satnogs_doppler_compensation_0_0, '0', iocp_endurosat_TAG_TRIGGER_0, '0']
- [satnogs_doppler_compensation_0_0, '0', limesdr_sink_0, '0']
- [satnogs_doppler_compensation_0_0, '0', qtgui_freq_sink_x_1_0_0, '0']
- [si446x_var_len_packet_handler_1_0, out, virtual_sink_4, '0']
- [var_len_packet_creator_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [virtual_source_0, '0', blocks_repack_bits_bb_1, '0']
- [virtual_source_0_0, '0', blocks_delay_0, '0']
- [virtual_source_0_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0_0_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0_1, '0', si446x_var_len_packet_handler_1_0, '0']
- [virtual_source_1, '0', analog_quadrature_demod_cf_0, '0']
- [virtual_source_2, '0', iocp_endurosat_IOCP_CLIENT_PDU_0, in]
- [virtual_source_2_0, '0', iocp_endurosat_IOCP_CLIENT_PDU_0, event]
- [virtual_source_4, '0', var_len_packet_creator_0, in]

metadata:
  file_format: 1
