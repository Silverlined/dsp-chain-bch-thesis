options:
  parameters:
    author: surligas
    generate_options: no_gui
    id: bpsk_ber
    output_language: python
    run_options: run
    title: BPSK BER Simulation
  states: {}

blocks:
- name: nfilts
  id: variable
  parameters:
    value: '128'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: variable_ieee802_15_4_encoder_0
  id: variable_ieee802_15_4_encoder
  parameters:
    crc: satnogs.crc.CRC32_C
    preamble: '0x55'
    preamble_len: '12'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: variable_ieee802_15_4_variant_decoder_0
  id: variable_ieee802_15_4_variant_decoder
  parameters:
    crc: satnogs.crc.CRC32_C
    drop_invalid: 'True'
    frame_len: '255'
    preamble: '[0x55]*12'
    preamble_thrsh: '14'
    sync_thrsh: '5'
    sync_word: '[79, 121, 97]'
    var_len: 'True'
    whitening: satnogs.whitening.make_ccsds(True)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_POISSON
    mean: '1'
    msg: pmt.intern("TEST")
    std: '1'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps * 8
    lengthtagname: packet_len
    type: complex
  states: {}
- name: cfo
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: cfo/(samp_rate*sps)
    noise_voltage: math.sqrt(  (sps*(2*math.log2(variable_constellation_0.arity()))) * math.pow(10, -snr/10))
    seed: '0'
    taps: 1 + 1j
  states: {}
- name: digital_burst_shaper_xx_0_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'True'
    length_tag_name: '"packet_len"'
    post_padding: '1000'
    pre_padding: '0'
    type: complex
    window: ([])
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: variable_constellation_1
    fmax: '0.1'
    fmin: '-0.1'
    loop_bw: 2.0 * math.pi/200.0
    showports: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2.0 * math.pi/200.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.001'
    msg_nsamples: '1000'
    type: '0'
  states: {state: disabled}
- name: excess_bw
  id: parameter
  parameters:
    comment: |-
      The BPSK excess bandwidth setup.
      Used in filtering.
    type: eng_float
    value: '0.35'
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate*1.35
    decim: '1'
    gain: '1'
    samp_rate: samp_rate * sps
    type: fir_filter_ccf
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate * sps
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: satnogs_ber_calculator_0
  id: satnogs_ber_calculator
  parameters:
    frame_size: '64'
    nframes: '10000'
    skip: '10'
  states: {}
- name: satnogs_constellation_modulator_0
  id: satnogs_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: satnogs_frame_decoder_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ieee802_15_4_variant_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_encoder_0
  id: satnogs_frame_encoder
  parameters:
    encoder_object: variable_ieee802_15_4_encoder_0
  states: {}
- name: snr
  id: parameter
  parameters:
    type: eng_float
    value: '12'
  states: {}
- name: sps
  id: parameter
  parameters:
    label: samples per symbol
    type: intx
    value: '8'
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, satnogs_ber_calculator_0, trigger]
- [blocks_pdu_to_tagged_stream_0, '0', satnogs_constellation_modulator_0, '0']
- [blocks_tagged_stream_align_0, '0', digital_burst_shaper_xx_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', blocks_tagged_stream_align_0, '0']
- [channels_channel_model_0, '0', low_pass_filter_0, '0']
- [digital_burst_shaper_xx_0_0, '0', channels_channel_model_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '1']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '2']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', satnogs_frame_decoder_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, blocks_message_debug_0, print]
- [low_pass_filter_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [satnogs_ber_calculator_0, pdu, satnogs_frame_encoder_0, pdu]
- [satnogs_constellation_modulator_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [satnogs_frame_decoder_0, out, satnogs_ber_calculator_0, received]
- [satnogs_frame_encoder_0, pdu, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
