options:
  parameters:
    author: EnduroSat
    copyright: EnduroSat
    generate_options: qt_gui
    id: BER_Simulation
    output_language: python
    title: BER_Simulation
  states: {}

blocks:
- name: prn_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: UHF_GMSK_Demod_Hier_0
  id: UHF_GMSK_Demod_Hier
  parameters:
    agc_reference: '1.0'
    baudrate: int(9.6e3)
    clk_bw: '0.06'
    clk_limit: '0.004'
    cutoff_freq: '9600'
    deviation: '2400'
    lp_decimation: '5'
    rms_alpha: '0.02'
    ted_gain: '1.47'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: prn_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: gr.sizeof_float
    type: float
    vlen: prn_len
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: float
    window: window.rectangular(1024)
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_vector_source_x_1, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
