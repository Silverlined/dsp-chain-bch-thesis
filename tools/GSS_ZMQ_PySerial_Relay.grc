options:
  parameters:
    author: EnduroSat
    generate_options: no_gui
    id: GSS_ZMQ_PySerial_Relay
    output_language: python
    title: GSS_ZMQ_PySerial_Relay
  states: {}

blocks:
- name: iocp_endurosat_IOCP_DOWNLINK_PDU_0
  id: iocp_endurosat_IOCP_DOWNLINK_PDU
  parameters:
    address: 127.0.0.1
    port: '6666'
  states: {}
- name: iocp_endurosat_IOCP_UPLINK_PDU_0
  id: iocp_endurosat_IOCP_UPLINK_PDU
  parameters:
    address: 127.0.0.1
    port: '6666'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_0_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:6002
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:6002
    timeout: '100'
  states: {}

connections:
- [iocp_endurosat_IOCP_UPLINK_PDU_0, out, satellites_hexdump_sink_0, in]
- [iocp_endurosat_IOCP_UPLINK_PDU_0, out, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, iocp_endurosat_IOCP_DOWNLINK_PDU_0, in]
- [zeromq_pull_msg_source_0, out, satellites_hexdump_sink_0_0, in]

metadata:
  file_format: 1
